Commit message: modify lidar tf

File: resource/robot.urdf (robot description, URDF)
Before this commit: robot tiago, 4 links, 3 joints
Joints:
- joint lidar_joint: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0.25 0 0.25 rpy=0 0 0; type fixed -> None
